

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.455 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.18855 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.23232 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.16351 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 5.74223 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.351 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.68831 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.88 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.4752 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.304 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.65464 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.760285 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 3.80272 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST 
    ANTENNAPARTIALMETALAREA 1.411 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.78691 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.258 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.9134 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 239.287 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1158.33 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END RST
  PIN RX_IN 
    ANTENNAPARTIALMETALAREA 4.859 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.5642 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6734 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 21.5161 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 98.3771 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.03078 LAYER VIA34 ;
  END RX_IN
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.385 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.66185 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.735 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.53775 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 13.0462 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 64.1689 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.617094 LAYER VIA34 ;
  END SE
  PIN SI 
    ANTENNAPARTIALMETALAREA 13.452 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.7041 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.393 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.89273 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 40.2561 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 203.81 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA45 ;
  END SI
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 1.517 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.29677 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 18.868 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 89.7508 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.414466 LAYER VIA23 ;
  END test_mode
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.354 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5151 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.903618 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 4.42933 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 9.899 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.6142 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 188.743 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 904.388 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 11.29 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.8821 LAYER METAL3 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 259.35 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1247.62 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END scan_rst
  PIN test_si2 
    ANTENNAPARTIALMETALAREA 2.632 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6599 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 52.4015 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 248.585 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END test_si2
  PIN test_si3 
    ANTENNAPARTIALMETALAREA 1.648 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.92688 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 9.607 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.4021 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 5.917 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.6532 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 157.223 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 767.217 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END test_si3
  PIN test_si4 
    ANTENNAPARTIALMETALAREA 0.114 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.54834 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.033 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7811 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 66.3039 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 326.285 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END test_si4
  PIN test_si5 
    ANTENNAPARTIALMETALAREA 1.261 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.06541 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.199 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.6296 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 180.488 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 875.51 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA45 ;
  END test_si5
  PIN TX_OUT 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 7.306 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1419 LAYER METAL3 ;
  END TX_OUT
  PIN PAR_ERR 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.976 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.50456 LAYER METAL3 ;
  END PAR_ERR
  PIN STP_ERR 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.648 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.92688 LAYER METAL3 ;
  END STP_ERR
  PIN SO 
    ANTENNAPARTIALMETALAREA 0.114 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.54834 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.168 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.00048 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 5.516 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.7244 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 42.4203 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 204.692 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.19672 LAYER VIA45 ;
  END SO
  PIN test_so2 
    ANTENNAPARTIALMETALAREA 0.114 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.54834 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.229 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.10389 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.537 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 9.78 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 47.2342 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 75.9057 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 369.999 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 3.57177 LAYER VIA67 ;
  END test_so2
  PIN test_so3 
    ANTENNAPARTIALMETALAREA 2.956 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2184 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.732 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9533 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1196 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 48.8871 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 237.537 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.81104 LAYER VIA34 ;
  END test_so3
  PIN test_so4 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.19 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.1539 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 1.124 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.59884 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 11.861 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 57.4362 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4641 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 46.9115 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 232.365 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.22575 LAYER VIA56 ;
  END test_so4
  PIN test_so5 
    ANTENNAPARTIALMETALAREA 0.114 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.54834 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.168 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.00048 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 13.716 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.1664 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 104.511 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 503.036 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.37505 LAYER VIA45 ;
  END test_so5
END SYS_TOP

END LIBRARY
